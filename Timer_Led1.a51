ORG 0000H
	START:	MOV	R1,#08H
			
	MOV	A,#00000001B
	LEFT:	MOV	P1,A
			ACALL	DELAY
			RL	A
			DJNZ	R1,LEFT
			MOV	R1,#08H
			MOV A,#10000000B
	RIGHT:	MOV	P1,A
			ACALL	DELAY
			RR	A
			DJNZ	R1,RIGHT
			
			AJMP	START
			
	DELAY:	MOV	R4,#50
			MOV	TMOD,#01H
	TIMER:	MOV	TH0,#3CH
			MOV	TL0,#0B0H
			SETB	TR0
	WAIT:	JB	TF0,OK
			AJMP	WAIT
	OK:		CLR	TF0
			DJNZ	R4,TIMER
			RET
	END