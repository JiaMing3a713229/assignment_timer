# Keil uVision project timer_practice.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: timer_practice
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../: flash_led_timer.a51 Timer_LED.a51
    ./: Timer_Led1.a51
